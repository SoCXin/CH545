# Keil uVision project CH545.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH545 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(48000000)
  output: CH545 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: DEBUG
  c include: .\ADC;.\DATAFLASH;.\Public;.\RGB;.\SPI;.\TIMER;.\TOUCHKEY;.\UART;.\USB\USB_LIB;.\USB\Host
  asm include: .\Public
  group main
    ./ADC/: ADC.C MAIN.C
  group pub
    ./Public/: Debug.C
