# Keil uVision project CH545.uvproj, settings and files
target Target 1 (MCS-51)
  device: AX11015 ASIX Electronics Corporation
  cpu: IRAM(0-0xFF) CLOCK(100000000) MOD_CONT MODDA MODDP2 XRAM (0xF000-0xFFFF)
  output: CH545 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ADC;.\Public;.\GPIO;.\UART;.\USB;.\RGB;.\SPI;.\DATAFLASH;.\TIMER;.\TouchKey;.\USB\USB_LIB;.\抓取脉冲
  asm include: .\Public
  group main
    ./GPIO/: GPIO.c MAIN.c
  group pub
    ./Public/: Debug.C
