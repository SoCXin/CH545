# Keil uVision project CH545.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH533 WCH
  cpu: IRAM(0-0xFF)   IROM(0-0x3FFF) CLOCK(15000000)
  output: GPIO +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: DEBUG
  c include: .\ADC;.\DATAFLASH;.\Public;.\RGB;.\SPI;.\TIMER;.\TOUCHKEY;.\UART;.\USB\USB_LIB;.\USB\Host
  asm include: .\Public
  group pub
    ./Public/: Debug.C
